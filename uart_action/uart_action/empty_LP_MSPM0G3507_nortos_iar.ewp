# IAR project empty_LP_MSPM0G3507_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSPM0G3507 TexasInstruments MSPM0G3507
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __MSPM0G3507__
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; $MSPM0_SDK_INSTALL_DIR$/source/third_party/CMSIS/Core/Include; $MSPM0_SDK_INSTALL_DIR$/source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$
  ILINK.IlinkOutputFile: empty_LP_MSPM0G3507_nortos_iar.out
  ILINK.IlinkIcfFile: mspm0g3507.icf
  ILINK.IlinkExtraOptions: -L$MSPM0_SDK_INSTALL_DIR$/source; -L$PROJ_DIR$; $MSPM0_SDK_INSTALL_DIR$/source/ti/driverlib/lib/iar/m0p/mspm0g1x0x_g3x0x/driverlib.a; --silent
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: SysConfig_Generated_Files.ipcf
  group empty
    ./: callback.c empty.c empty.syscfg Font.h Lcd.c Lcd.h mspm0g3507.icf my_fun.c README.html README.md
  group empty/iar
    iar/: startup_mspm0g350x_iar.c
  group SysConfig Generated Files
    ./: Event.dot ti_msp_dl_config.c ti_msp_dl_config.h
